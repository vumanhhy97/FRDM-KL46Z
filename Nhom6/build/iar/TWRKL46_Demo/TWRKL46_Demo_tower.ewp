# IAR project TWRKL46_Demo_tower.ewp, settings and files
configuration FLASH_256KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TOWER; TWR_REVA
  ICCARM.CCIncludePath2: ..\..\..\src\projects\TWRKL46_Demo; ..\..\..\src\projects\TWRKL46_Demo\rtc; ..\..\..\src\projects\TWRKL46_Demo\LCD; ..\..\..\src\projects\TWRKL46_Demo\i2c; ..\..\..\src\projects\TWRKL46_Demo\angle_calculation; ..\..\..\src\projects\TWRKL46_Demo\adc16; ..\..\..\src\projects\TWRKL46_Demo\adc_test; ..\..\..\src\projects\TWRKL46_Demo\median; ..\..\..\src\projects\TWRKL46_Demo\tsi; ..\..\..\src\projects\TWRKL46_Demo\task_mgr; ..\..\..\src\projects\TWRKL46_Demo\pit; ..\..\..\src\projects\TWRKL46_Demo\bsp; ..\..\..\src\projects\TWRKL46_Demo\usb; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\platforms; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TWRKL46_Demo_tower.srec
  ILINK.IlinkOutputFile: platinum_firebird.out
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: IAR; TOWER
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: IAR; TOWER
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: IAR; TOWER
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: IAR; TOWER
  ILINK.IlinkIcfFile: ..\config files\32KB_RAM.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL46Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/TWRKL46_Demo/: FslTypes.h global.c global.h GPIO.c GPIO.h isr.h TWRKL46_Demo.c
  group project/adc16
    ../../../src/projects/TWRKL46_Demo/adc16/: adc16.c adc16.h
  group project/adc_test
    ../../../src/projects/TWRKL46_Demo/adc_test/: adc_test.c adc_test.h
  group project/angle_calculation
    ../../../src/projects/TWRKL46_Demo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h sqrt16.c sqrt16.h
  group project/bsp
    ../../../src/projects/TWRKL46_Demo/bsp/: bsp_KL25.c bsp_KL25.h
  group project/i2c
    ../../../src/projects/TWRKL46_Demo/I2C/: hal_dev_mma8451.c hal_dev_mma8451.h hal_i2c.c hal_i2c.h
  group project/LCD
    ../../../src/projects/TWRKL46_Demo/lcd/: GD-6363P.c LCD.h LCD_HAL.h LCDConfig.h LcdDrv.c TWRPI-GD6363P.h
  group project/median
    ../../../src/projects/TWRKL46_Demo/median/: median.c median.h
  group project/pit
    ../../../src/projects/TWRKL46_Demo/pit/: pit.c pit.h
  group project/rtc
    ../../../src/projects/TWRKL46_Demo/rtc/: rtc.c rtc.h
  group project/task_mgr
    ../../../src/projects/TWRKL46_Demo/task_mgr/: task_mgr.c task_mgr.h
  group project/tsi
    ../../../src/projects/TWRKL46_Demo/tsi/: TSIDrv.c TSIDrv.h
  group project/usb
    ../../../src/projects/TWRKL46_Demo/usb/: ring_buffer.c ring_buffer.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_reg.c usb_reg.h

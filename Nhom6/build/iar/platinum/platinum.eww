<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\platinum_freedom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\platinum_tower.ewp</path>
  </project>
   <batchBuild/>
</workspace>



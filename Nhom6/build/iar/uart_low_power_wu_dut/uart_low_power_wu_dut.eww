<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uart_low_power_wu_dut_freedom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uart_low_power_wu_dut_tower.ewp</path>
  </project>
   <batchBuild/>
</workspace>



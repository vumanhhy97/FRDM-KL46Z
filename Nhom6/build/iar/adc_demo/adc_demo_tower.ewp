# IAR project adc_demo_tower.ewp, settings and files
configuration FLASH_256KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\i2c; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: platinum_firebird.srec
  ILINK.IlinkOutputFile: platinum_firebird.out
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\i2c; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\cmp; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\32KB_RAM.icf
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
configuration RAM_8KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\8KB_RAM.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL46Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 256KB_Pflash.icf 32KB_Pflash.icf 32KB_RAM.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/adc_demo/: adc_demo.c isr.h
